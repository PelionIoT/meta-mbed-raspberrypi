SRCREV = "a705ebc81b7f91bbd0ef7c634284208342901149"

PV = "v2017.01+git${SRCPV}"