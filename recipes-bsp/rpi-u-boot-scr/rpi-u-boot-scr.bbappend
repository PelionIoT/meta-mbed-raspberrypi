FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

#SRC_URI_append = " file://0001-add-saveenv.patch "
SRC_URI_append = " file://boot.cmd "
