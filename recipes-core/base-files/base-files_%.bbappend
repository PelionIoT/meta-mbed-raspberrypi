FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

SRC_URI_append = " file://fstab file://profile "
